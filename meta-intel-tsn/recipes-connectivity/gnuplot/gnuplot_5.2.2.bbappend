EXTRA_OECONF += "--without-lisp-files"
