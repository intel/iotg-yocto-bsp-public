PACKAGECONFIG_append = " xz"
