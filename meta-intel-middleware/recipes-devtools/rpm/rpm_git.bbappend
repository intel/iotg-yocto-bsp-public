FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0001-Don-t-require-signature-header-to-be-in-single-conti.patch \
"
