INITSCRIPT_PARAMS = "start 99 . stop 20 0 1 2 3 5 6 ."
