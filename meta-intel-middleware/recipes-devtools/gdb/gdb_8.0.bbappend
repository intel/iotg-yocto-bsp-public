# Enable gdb TUI mode for debugging
EXTRA_OECONF_remove = "--disable-tui"
EXTRA_OECONF += " --enable-tui"
