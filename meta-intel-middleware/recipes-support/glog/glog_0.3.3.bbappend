FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

CFLAGS += " -D_GLIBCXX_USE_CXX11_ABI=0"
CXXFLAGS += " -D_GLIBCXX_USE_CXX11_ABI=0"
