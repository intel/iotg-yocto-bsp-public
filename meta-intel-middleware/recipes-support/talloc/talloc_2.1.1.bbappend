# Overwrites default packages from the packages list
PACKAGES = "libtalloc libtalloc-dbg libtalloc-dev libtalloc-doc pytalloc pytalloc-dbg pytalloc-dev"

FILES_libtalloc-doc = "${datadir}"
