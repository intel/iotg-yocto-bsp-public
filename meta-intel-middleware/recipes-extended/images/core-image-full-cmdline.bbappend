DESCRIPTION = "Custom list of packages for build essentials"

IMAGE_INSTALL_append = " packagegroup-core-buildessential-extended"
