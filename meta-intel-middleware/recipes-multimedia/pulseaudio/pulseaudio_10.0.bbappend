FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-default.pa-Use-the-custom-settings-for-APL.patch"
