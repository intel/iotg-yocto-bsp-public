FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Do-not-check-GST_IS_PUSH_SRC-element-for-sinkpad-dma.patch"
