DISABLE_STATIC = ""
