SRC_URI = "https://pypi.python.org/packages/source/j/${SRCNAME}/${SRCNAME}-${PV}.zip"
