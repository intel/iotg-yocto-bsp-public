FILESEXTRAPATHS_append := "${THISDIR}/${PN}"
SRC_URI_append = "file://xf86-video-intel_version_diff.patch"
