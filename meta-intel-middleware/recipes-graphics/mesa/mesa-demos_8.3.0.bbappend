PACKAGES_prepend = "mesa-glxinfo "
FILES_mesa-glxinfo = "${bindir}/glxinfo"
RDEPENDS_mesa-glxinfo = "mesa"
