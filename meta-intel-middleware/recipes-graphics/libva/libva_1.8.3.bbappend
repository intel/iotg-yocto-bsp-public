SRCREV = "8f1091e4a6515f8e031b89d13a2ebc0835fa9b26"

RRECOMMENDS_${PN} += " libva-utils"
